## drivers/rtk_kdriver/vdec/Kconfig
```kconfig
config RTK_KDRV_VDEC
	tristate "Driver for VDEC HAL Manager"
	depends on RTK_KDRV_RPC
	default n
	help
	  Driver for VDEC HAL Manager
```
